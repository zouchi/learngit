# IAR project GenericRKE_HT3.ewp, settings and files
configuration Debug (MRK-II, debug)
  General.GenCStackSize: 0x20
  General.GenHeapSize: 0x20
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.OGChipSelectMenu: PCF7961X_E PCF7961X/E
  ICCMRKII.CCDefines: __MRKII_PCF7961
  ICCMRKII.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AMRKII.AsmStdIncludePath: $TOOLKIT_DIR$\INC\
  AMRKII.AsmIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkPCF7961__E.xcl
configuration Release (MRK-II)
  as the first configuration, except:
  ICCMRKII.CCDefines: NDEBUG; __MRKII_PCF7961
  XLINK.XlinkExtraOptions: -Ointel-standard,(CODE)=$EXE_DIR$\EROM.hex; -Ointel-standard,(XDATA)=$EXE_DIR$\eeprom.hex
  group (top)
    ./: buttons.c crypt.c data_dispatch.c ee_prom.c eeprom.s52 hardware.c hitag3.c main.c rke.c si.c timer.c transmit.c
